# Keil uVision project TIM2_PWM_DMA.uvprojx, settings and files
target MM32SPIN0280 (6180000::V6.18::ARMCLANG)
  device: MM32SPIN0280D7P MindMotion
  pack: MindMotion.MM32SPIN0280_DFP.0.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MM32SPIN3280 +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_5V
  c include: ..\..\..\Device\Include;..\..\..\Device\HAL_lib\inc;..\..\..\Device\CMSIS\KEIL_Core;..\BSP_DRV\inc;..\SYSTEM\inc;..\USER\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ../../../Device/: system_mm32spin028x.c startup_mm32spin028x_keil.s
  group HAL_Lib
    ../../../Device/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_comp.c hal_crc.c hal_csm.c hal_dac.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_opamp.c hal_pwr.c hal_rcc.c hal_spi.c hal_sqrt.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group BSP_DRV
    ../BSP_DRV/: board.c drv_led.c drv_uart.c
  group SYSTEM
    ../SYSTEM/: systick.c
  group USER
    ../USER/: main.c neopixel.c pwm_dma.c neopixel_animation.c bsp_led_pwm.c
